# Keil uVision project RX5808.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RX5808 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --diag_suppress=188,111,546,68
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE\inc;..\LVGL\lvgl;..\LVGL\lvgl\src;..\LVGL\lvgl\src\core;..\LVGL\lvgl\src\draw;..\LVGL\lvgl\src\font;..\LVGL\lvgl\src\gpu;..\LVGL\lvgl\src\hal;..\LVGL\lvgl\src\misc;..\LVGL\lvgl\src\widgets;..\LVGL\lvgl\src\extra;..\LVGL\lvgl\src\extra\themes\basic;..\LVGL\lvgl\src\extra\themes\default;..\LVGL\lvgl\src\extra\themes\mono;..\LVGL\lvgl_app;..\LVGL\lvgl_driver;..\LVGL\GUI_Page;..\LVGL\lvgl\src\draw\sw
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c
    ../HARDWARE/inc/: include.h
  group HARDWARE
    ../HARDWARE/src/: lcd.c ws2812.c systick_delay.c system.c beep.c key.c rx5808.c iwdg.c stmf4flash.c rx5808_config.c soft_iic.c 24cxx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f411xe.s system_stm32f4xx.c stm32f4xx_it.c
  group LVGL
    ../LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/lvgl/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw.c
    ../LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_16.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font_simsun_16_cjk.c lv_font_montserrat_8.c
    ../LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/lvgl/src/hal/: lv_hal_indev.c lv_hal_tick.c lv_hal_disp.c
    ../LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/extra/: lv_extra.c
    ../LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group GUI
    ../LVGL/lvgl_driver/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lvgl_init.c
    ../LVGL/lvgl/: lv_conf.h
  group Page
    ../LVGL/GUI_Page/: page_start.c page_main.c page_menu.c page_setup.c page_scan.c page_scan_calib.c page_scan_chart.c page_scan_table.c page_about.c lvgl_stl.c
  group Resources
    ../LVGL/Resources/: menu_about_icon.c menu_rx_icon.c menu_setup_icon.c lock_img.c lv_font_fre.c lv_font_start.c lv_font_chinese_12.c lv_font_chinese_16.c
  group Readme
    ../: readme.txt
